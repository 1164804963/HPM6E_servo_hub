# Keil uVision project STM32H743VGT6_Y01.uvprojx, settings and files
target STM32H743VGT6_Y01 (6150000::V6.15::ARMCLANG)
  device: STM32H743VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x807FFFF) IROM2(0x8100000-0x817FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H743VGT6_Y01 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../../../database;../../../board_public;../../../common/math_lib;../../../common/ring_buff;../../../common/software_scope;../../../common/unit_conversion;../../../communication/callback/MAVLink;../../../communication/callback/cia402_od;../../../communication/protocol/MAVLink;../../../communication/protocol/MAVLink/servo_hub_database;../../../communication/protocol/CiA402/PDS_FSA;../../../communication/protocol/CANopen;../../../communication/protocol/CANopen/inc;../../../communication/protocol/CANopen/inc/hw_cm7;../../../communication/protocol/CANopen/SlaveOD;../../../communication/protocol/EtherCAT_LAN925x;../../../communication/protocol/EtherCAT_LAN925x/Src;../../../simulink_code_gen;../../../motor_control;../Board;../Board/EtherCAT;../../../app;../../../app/Identify;../../../board_public/flash_db/inc;../../../board_public/flash_db/port/fal/inc;../../../board_public/system_manage
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\STM32H743VGT6_Y01.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_qspi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group system_manage
    ../../../board_public/system_manage/: system_init.c
  group app
    ../../../app/Identify/: app_id_dir_mode.c app_id_elec_angle_mode.c app_id_elec_mode.c app_id_mec_mode.c app_id_pole_pairs_mode.c app_id_tq_fc_mode.c
    ../../../app/: app_brake_control.c app_cyclic_sync_position_mode.c app_cyclic_sync_torque_mode.c app_cyclic_sync_velocity_mode.c app_homing_mode.c app_mit_mode.c app_motion_precondition.c app_profile_position_mode.c app_profile_torque_mode.c app_profile_velocity_mode.c app_scheduler.c app_status_check.c app_store_param.c app_trajectory.c
  group database
    ../../../database/: data_param.c
  group board
    ../Board/: board.c bsp_api.c bsp_fdcan.c bsp_flash.c bsp_nor_flash.c drv_can_app.c drv_encoder.c drv_nor_flash.c drv_upgrade.c system_timer.c servo_system_cfg.h version.h
  group motor_control
    ../../../motor_control/: motor_ctl_loop.c motor_ctl_sm.c
    ../../../simulink_code_gen/: current_ctl_loop_task.c database_init.c direction_id.c elec_angle_id.c input_shaping_ei.c linear_trajectory_planning.c load_pos_sensor.c math_lib.c mit_ctl.c motor_pos_sensor.c notch_filter.c notch_filter_config_set.c pole_pairs_id.c pos_speed_ctl_pip.c pos_trajectory_planning.c protect_check.c reciprocal_motion.c reference_signal.c rt_urand_Upu32_Yd_f_pw.c servo_hub_example.c speed_obs_pll.c sim_plant.c tq_fc_id.c csv_planning.c csp_planning.c cst_planning.c
  group communication
    ../../../communication/callback/mavlink/: mavlink_callback.c mavlink_scope_interface.c
    ../../../communication/callback/ethercat/: ecat_callback.c
    ../../../communication/callback/cia402_od/: Cia402_ObjectDictionary_Callback.c Cia402_ObjectDictionary_Variable.c master_cia402_callback.c
    ../../../communication/callback/canopen/: canopen_callback.c
  group communication/cia402
    ../../../communication/protocol/CiA402/PDS_FSA/: cia402_error_code.c cia402_fsm.c cia402_statusword.c
  group communication/canopen
    ../../../communication/protocol/CANopen/SlaveOD/: SlaveOD.c
    ../../../communication/protocol/CANopen/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group communication/ethercat
    ../Board/EtherCAT/: ecat_app_hw.c ecat_drv_sqi.c
    ../../../communication/protocol/EtherCAT_LAN925x/: ecat_app.c
    ../../../communication/protocol/EtherCAT_LAN925x/Src/: bootmode.c coeappl.c ecatappl.c ecatcoe.c ecateoe.c ecatfoe.c ecatslv.c emcy.c eoeappl.c foeappl.c mailbox.c objdef.c sdoserv.c
  group software_scope
    ../../../common/software_scope/: scope_app.c scope_map.c waveform_app.c
  group board_public/flash_db
    ../../../board_public/flash_db/port/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ../../../board_public/flash_db/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group utilities
    ../../../common/ring_buff/: ringbuffer.c
    ../../../common/unit_conversion/: unit_conversion.c coordinate_conversion.c
target YH_CANOPEN (6150000::V6.15::ARMCLANG)
  device: STM32H743VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: as above
  output: STM32H743VGT6_Y01 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7,MINOR_VERSION=V_CANOPEN_CIA402
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\STM32H743VGT6_Y01.sct
target YH_ETHERCAT (6150000::V6.15::ARMCLANG)
  device: STM32H743VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: as above
  output: STM32H743VGT6_Y01 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7,MINOR_VERSION=V_ECAT_CIA402
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\STM32H743VGT6_Y01_ECAT.sct
target YH_CANOPEN_RELEASE (6150000::V6.15::ARMCLANG)
  device: STM32H743VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: as above
  output: STM32H743VGT6_Y01 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  AfterMake: ..\FwProcess\FwCalcCrc32.bat
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7,MINOR_VERSION=V_CANOPEN_CIA402,YH_RELEASE
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\STM32H743VGT6_Y01_RELEASE.sct
target YH_ETHERCAT_RELEASE (6150000::V6.15::ARMCLANG)
  device: STM32H743VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: as above
  output: STM32H743VGT6_Y01 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  AfterMake: ..\FwProcess\FwCalcCrc32.bat
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7,MINOR_VERSION=V_ECAT_CIA402,YH_RELEASE
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\STM32H743VGT6_Y01_RELEASE.sct
target YH_VIRTUAL_MOTOR_MODEL (6150000::V6.15::ARMCLANG)
  device: STM32H743VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: as above
  output: STM32H743VGT6_Y01 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7,VIRTUAL_MOTOR_MODEL
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\STM32H743VGT6_Y01.sct
software components: CMSIS:DSP 1.8.0
